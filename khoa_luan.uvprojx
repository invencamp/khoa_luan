# Keil uVision project khoa_luan.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: khoa_luan
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\AppData\Local\Arm\Packs\ARM\CMSIS\6.2.0\CMSIS\Core\Include;..\AppData\Local\Arm\Packs\Keil\STM32L073Z-EVAL_BSP\1.1.0\Layers\Default\CubeMX\STM32CubeMX\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c startup_stm32l073xx.s stm32l073xx.h
